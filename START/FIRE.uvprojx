# Keil uVision project FIRE.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC_506)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FIRE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Thread_TEST.c Thread_TEST.h
  group LEDS
    ./: LEDS.c LEDS.h
  group PWM
    ./: PWM.c PWM.h
  group EEPROM
    ./: Memoria.c Memoria.h
  group MASTER
    ./: Master.c Master.h
  group UART
    ./: UART.c UART.h UART_RX.c UART_RX.h
  group WEB
    ./: HTTP_Server.c HTTP_Server_CGI.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS Driver:I2C 2.10, CMSIS Driver:USART 2.13, Compiler:Event Recorder 1.4.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
